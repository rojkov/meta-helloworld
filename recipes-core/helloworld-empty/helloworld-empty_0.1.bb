SUMMARY = "Hello world recipe"
LICENSE = "MIT"

DEPENDS = "curl-native"
